## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes misc-modules and scull drivers as .ko and 
	  automatically load/unload them.
```
